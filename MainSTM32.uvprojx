# Keil uVision project MainSTM32.uvprojx, settings and files
target MainSTM32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MainSTM32
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  MainSTM32.bin   Objects\MainSTM32.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\NewMainSTM32
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c ringbuffer.c usart1.c usart2.c usart3.c can1.c protocol.c custom.c systick.c systick.h
  group Header
    ./: can1.h custom.h protocol.h ringbuffer.h usart1.h usart2.h usart3.h
software components: CMSIS:CORE 5.0.0, CMSIS Driver:CAN 1.2, CMSIS Driver:USART 2.2, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0
