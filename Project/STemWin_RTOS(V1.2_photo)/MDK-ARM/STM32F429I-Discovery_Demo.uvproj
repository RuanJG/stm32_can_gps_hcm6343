# Keil uVision project STM32F429I-Discovery_Demo.uvproj, settings and files
target STM32F429I-Discovery_Demo (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429I-Discovery_Demo +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO,USE_USB_OTG_HS ,USE_EMBEDDED_PHY,
  c misc: --c99 --diag-suppress 111
  c include: .\..\Config;.\..\Core\Devices\STM32F4xx;.\..\Core\User;.\..\Core\Demo;.\..\Core\Lib;.\..\Core\Test_Program;.\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;.\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;.\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;.\..\..\..\Libraries\STM32_USB_Device_Library\Class\MSC\inc;.\..\..\..\Libraries\STM32_USB_Device_Library\Class\HID\inc;.\..\..\..\Libraries\STM32_USB_Device_Library\Class\Audio\inc;.\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;.\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\..\..\..\Utilities;.\..\..\..\Utilities\Common;.\..\..\..\Utilities\STM32F429i-Discovery;.\..\..\..\Utilities\Third_Party\fat_fs\inc;.\..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F;.\..\..\..\Utilities\Third_Party\FreeRTOS\Source\include;.\..\..\..\Libraries\STemWinLibrary522_4x9i\inc;.\..\..\..\Libraries\STemWinLibrary522_4x9i\Config;..\Core\User\TouchPanel;..\Core\Demo5.22\;..\Core\User\GUI\PNG
  asm include: .\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Appli
    ./../Core/User/: bsp.c fatfs_drv.c main.c rtc.c stm32xxx_it.c usb_bsp.c usbh_usr.c
    ./../Core/Devices/STM32F4xx/: system_stm32f4xx.c
    ./../Core/Lib/: cpu_utils.c file_utils.c str_utils.c time_utils.c
    ./: startup_stm32f429_439xx.s
    ../Core/User/TouchPanel/: TouchPanel.c
    ../Core/Test_Program/: test_program.c usbd_desc.c usbd_usr.c
    ../Core/User/GUI/PNG/: zutil.c uncompr.c adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c
  group Libraries
    ./../../../Libraries/STemWinLibrary522_4x9i/Config/: GUIConf.c
    ./../../../Libraries/STemWinLibrary522_4x9i/OS/: GUI_X_FreeRTOS.c
    ./../../../Utilities/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_ioe.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
    ./../../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
    ./../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
    ./../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ./../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../../../Libraries/STemWinLibrary522_4x9i/Lib/: STemWin522_4x9i_CM4_OS_Keil.lib
    ../../../Libraries/STemWinLibrary522_4x9i/Config/: GUIDRV_stm32f429i_discovery.c
    ../../../Utilities/STM32F429I-Discovery/: stm32f429i_discovery_l3gd20.c
  group Utilities
    ./../../../Utilities/Third_Party/fat_fs/src/: ff.c
    ./../../../Utilities/Third_Party/fat_fs/src/option/: syscall.c
    ./../../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ./../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port_cm4.c
  group Demo5.22
    ../Core/Demo5.22/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
