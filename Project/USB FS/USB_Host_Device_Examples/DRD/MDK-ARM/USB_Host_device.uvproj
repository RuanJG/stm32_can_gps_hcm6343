# Keil uVision project USB_Host_device.uvproj, settings and files
target Open4X9I-C (ARM-ADS)
  device: STM32F429II STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: STM324xG-EVAL_FS +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM324x9I_EVAL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\..\Libraries\STM32_USB_Device_Library\Class\MSC\inc;..\..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL;..\..\..\..\..\Utilities\Third_Party\fat_fs1\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../src/: stm32fxxx_it.c usb_bsp.c usbd_usr.c dual_func_demo.c main.c usbd_storage_msd.c usbh_msc_usr.c usbd_desc.c
  group USB Driver
    ../../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group USB Device
    ../../../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../../../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB Host
    ../../../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group STM32_EVAL
    ../../../../../Utilities/STM32_EVAL/Common/: lcd_log.c
    ../../../../../Utilities/STM32_EVAL/STM324x9I_EVAL/: stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm324x9i_eval.c stm324x9i_eval_sdio_sd.c
  group STM32F4xx
    ../src/: system_stm32f4xx.c
    ../../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FAT FS
    ../../../../../Utilities/Third_Party/fat_fs1/src/: ff.c fattime.c
