# Keil uVision project Project.uvprojx, settings and files
target STM32F429_439xx (ARM-ADS)
  device: STM32F429II STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: STM32F429_439xx
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM324x9I_EVAL,
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL;..\Bsp;..\uCos-II\port;..\uCos-II\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_cryp.c stm32f4xx_cryp_des.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_hash.c stm32f4xx_hash_sha1.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_sai.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_adc.c stm32f4xx_cryp_aes.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_hash_md5.c stm32f4xx_rtc.c stm32f4xx_cryp_tdes.c stm32f4xx_ltdc.c stm32f4xx_syscfg.c stm32f4xx_fmc.c
  group User
    ../: main.c stm32f4xx_it.c KEY&LED.c usart.c OS_AppHooks.c
    ../../../Utilities/STM32_EVAL/STM324x9I_EVAL/: stm324x9i_eval.c
  group uC-OS-II/Port
    ../uCos-II/port/: os_cpu_c.c os_dbg.c os_cpu_a.asm os_cpu.h
  group uC-OS-II/Source
    ../uCos-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
