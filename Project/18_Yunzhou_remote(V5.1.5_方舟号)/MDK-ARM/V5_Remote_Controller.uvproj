# Keil uVision project V5_Remote_Controller.uvproj, settings and files
target Yunzhou_Remote_Controller_V5.0 (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Yunzhou_Remote_Controller +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO,USE_USB_OTG_HS,USE_EMBEDDED_PHY, GPS_COOPERATE=HOME, HOME
  c misc: --c99 --diag-suppress 111
  c include: .\..\Config;.\..\Core\Devices\STM32F4xx;.\..\Core\User;.\..\Core\Demo;.\..\Core\Lib;.\..\Core\Test_Program;.\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;.\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;.\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;.\..\..\..\Libraries\STM32_USB_Device_Library\Class\MSC\inc;.\..\..\..\Libraries\STM32_USB_Device_Library\Class\HID\inc;.\..\..\..\Libraries\STM32_USB_Device_Library\Class\Audio\inc;.\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;.\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\..\..\..\Utilities;.\..\..\..\Utilities\Common;.\..\..\..\Utilities\STM32F429i-Discovery;.\..\..\..\Utilities\Third_Party\fat_fs\inc;.\..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F;.\..\..\..\Utilities\Third_Party\FreeRTOS\Source\include;.\..\..\..\Libraries\STemWinLibrary522_4x9i\inc;.\..\..\..\Libraries\STemWinLibrary522_4x9i\Config;..\Core\User\TouchPanel;..\Core\Demo5.22\
  asm include: .\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Appli
    ./../Core/User/: bsp.c fatfs_drv.c main.c rtc.c stm32xxx_it.c usb_bsp.c usbh_usr.c
    ./../Core/Devices/STM32F4xx/: system_stm32f4xx.c
    ./../Core/Lib/: cpu_utils.c file_utils.c str_utils.c time_utils.c
    ./: startup_stm32f429_439xx.s
    ../Core/User/TouchPanel/: TouchPanel.c
    ../Core/Test_Program/: usbd_desc.c usbd_usr.c
    ../Core/User/: SetUART.c SetADC.c UI_app.c keyboard_app.c joystick_app.c Xtend_900.c m_flash.c local_handle.c base64.c RFSession.c set_timer.c
  group Libraries
    ./../../../Libraries/STemWinLibrary522_4x9i/Config/: GUIConf.c
    ./../../../Libraries/STemWinLibrary522_4x9i/OS/: GUI_X_FreeRTOS.c
    ./../../../Utilities/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_ioe.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
    ./../../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
    ./../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
    ./../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ./../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../../../Libraries/STemWinLibrary522_4x9i/Lib/: STemWin522_4x9i_CM4_OS_Keil.lib
    ../../../Libraries/STemWinLibrary522_4x9i/Config/: GUIDRV_stm32f429i_discovery.c
  group Utilities
    ./../../../Utilities/Third_Party/fat_fs/src/: ff.c
    ./../../../Utilities/Third_Party/fat_fs/src/option/: syscall.c
    ./../../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ./../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port_cm4.c
target QC_Loop_Test (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  cpu: as above
  output: QC_Loop_Test +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO,USE_USB_OTG_HS,USE_EMBEDDED_PHY, QC_LOOP_TEST
  c misc: --c99 --diag-suppress 111
  c include: as above
  asm include: .\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target South_Satellite (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  cpu: as above
  output: South_Satellite +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO,USE_USB_OTG_HS,USE_EMBEDDED_PHY, GPS_COOPERATE = SOUTH_SATELLITE_RTK, SOUTH_SATELLITE_RTK
  c misc: --c99 --diag-suppress 111
  c include: as above
  asm include: .\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
